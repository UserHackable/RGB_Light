File: 4H-RGBLight.sch (EAGLE design)
At the start: 9 parts

Commit message: from Makefile
Parts:
- U$3: value 4H-LOGO6 -> (none)
